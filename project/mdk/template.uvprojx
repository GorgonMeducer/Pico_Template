# Keil uVision project template.uvprojx, settings and files
target AC6-flash (6240000::V6.24::ARMCLANG)
  device: RP2040:Core0 RPi
  pack: RaspberryPi.RP2xxx_DFP.0.9.5
  cpu: IRAM(0x20000000,0x00042000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template
  BeforeMake: $Stools\pio_all.bat
  AfterMake: $Stools\elf2uf2.exe "#L" ".\@L.uf2"
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: __RP2040_USE_BADGER__=1,__RP2040_USE_OLED_1IN3__=0,__RP2040_USE_LCD_1IN28__=0,__RP2040_USE_LCD_TOUCH_1IN28__=0,__PICO_USE_LCD_1IN3__=0,ITERATIONS=7000
  c include: .
  asm define: PICO_MAX_SHARED_IRQ_HANDLERS=4,LIB_CMSIS_CORE=1,PICO_CMSIS_RENAME_EXCEPTIONS=1
  asm include: ..\..\pico-sdk\src\rp2040\hardware_regs\include;..\..\pico-sdk\src\rp2_common\hardware_irq\include;..\..\pico-sdk\src\rp2_common\pico_platform\include;..\..\pico-sdk\src\common\pico_base\include;.\wrapper\pico_base;..\..\pico-sdk\src\rp2_common\boot_stage2\asminclude;..\..\pico-sdk\src\rp2_common\boot_stage2\include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x42000
  scatter file: .\RTE\Device\RP2040_Core0\rp2040.sct
  link misc: --diag_suppress=L6170,L6314,L6306,L6329
  group Application
    ../../: main.c
  group BSP
    ../../bsp/: bsp.h rp2040_bsp_default.c
    ../../bsp/lib/: RP2040_bsp.lib
target AC6-DebugInSRAM (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: RP2040:Core0 RPi
  pack: RaspberryPi.RP2xxx_DFP.0.9.5
  cpu: as above
  output: template
  AfterMake: $Stools\elf2uf2.exe "#L" ".\@L.uf2"
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: PICO, PICO_NO_FLASH, __PICO_USE_LCD_1IN3__=0
  c include: ..\mdk
  asm define: as above
  asm include: as above
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x42000
  scatter file: .\RP2040_debug_in_sram.sct
  link misc: --diag_suppress=L6170,L6314,L6306,L6329
software components: Acceleration:Arm-2D Extras:Controls 2.7.1, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.13.1, Acceleration:Arm-2D Helper:Display Adapter 3.5.0, Acceleration:Arm-2D Helper:PFB 2.8.1, Acceleration:Arm-2D:Alpha-Blending 1.2.4-dev, Acceleration:Arm-2D:Core 1.2.4-dev, Acceleration:Arm-2D:Filter 1.2.4-dev, Acceleration:Arm-2D:Transform 1.2.4-dev, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, Utilities:perf_counter:Core 2.5.3-dev, Device:Pico Board 1.5.1, Device:Pico SDK 1.5.1, Device:Startup 1.1.0
